# Keil uVision project 51Car.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 51Car +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c delay.c avoid.c buzzer.c direction.c int1.c time2.c track.c uart.c uartjudge.c radar.c time0.c pwm.c
